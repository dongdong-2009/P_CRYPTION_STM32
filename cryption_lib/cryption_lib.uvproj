# Keil uVision project cryption_lib.uvproj, settings and files
target Cryption_Lib_Debug (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sfz_stm32_output +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,ROC_RTC
  c include: .\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Driver\inc;.\STM32_USB-FS-Device_Driver\inc;.\USBHID\inc;.\SysTick;.\User;.\IROM;.\uart;.\hal_interface;.\app
  memory RVCT4: ROM 0x8000000 size 0x3a800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./app/: App_sfzCOM.c
  group User
    ./User/: main.c stm32f10x_it.c hardware.c
  group stdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group COMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./User/: system_stm32f10x.c
  group StartUp
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group SysTick
    ./SysTick/: SysTick_delay.c
  group IROM
    ./IROM/: IROM.c
  group usb_std_driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group usb_hid
    ./USBHID/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usbhid.c
  group UART
    ./uart/: hal_uart.c interFace_uart.c
  group General
    ./general/: base64.c Test.c sha256.c sha1.c Md5.c Rsa.c
